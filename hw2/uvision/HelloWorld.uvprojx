# Keil uVision project HelloWorld.uvprojx, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: firmware +hex
  AfterMake: fromelf --bin -o f:\HelloWorld_LPC1768.bin build\HelloWorld.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TARGET_MBED_LPC1768,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1413242107.71,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  mbed;  mbed/LPC1768;  mbed/LPC1768/ARM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/LPC1768/ARM/LPC1768.sct
  link misc: mbed/LPC1768/ARM/core_cm3.o
            
              mbed/LPC1768/ARM/cmsis_nvic.o
            
              mbed/LPC1768/ARM/system_LPC17xx.o
            
              mbed/LPC1768/ARM/sys.o
            
              mbed/LPC1768/ARM/startup_LPC17xx.o
            
              mbed/LPC1768/ARM/mbed.ar
            
              mbed/LPC1768/ARM/capi.ar
  group src
    ./: main.cpp
